# IAR project SD Logger.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER; __HW_VER_1__
  ICCARM.CCIncludePath2: $PROJ_DIR$; Application; System Core; System Core\Vectors; System Core\Include; STM32F10x_StdPeriph_Lib\STM32F10x_StdPeriph_Driver\inc; STM32F10x_Drivers_Lib\inc; Board; USB; SD Card; FatFs\source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: SD Logger.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: linker.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: $PROJ_DIR$; Application; System Core; System Core\Startup; System Core\Vectors; System Core\Include; StdPeriphLib\inc; Board; Board; Drivers\VirtualPort; Drivers\GPIO; Drivers\UART; Drivers\RTC; Drivers\EXTI; Drivers\NVIC; Drivers\SoftTimer; USB; SD Card; SD Card\FATFS
  OBJCOPY.OOCOutputFile: firmware.hex
  group Application
    Application/: config.cpp disk.cpp file.cpp main.cpp
  group Board
    Board/: board.cpp board.hpp
  group FatFs
    FatFs/source/: diskio.c ff.c ffconf.h ffsystem.c ffunicode.c
  group Linker
    ./: linker.icf
  group SD Card
    SD Card/: sdcard.c
  group STM32F10x_Drivers_Lib
    STM32F10x_Drivers_Lib/src/: exti.cpp gpio.cpp nvic.cpp rtc.cpp uart.cpp
  group STM32F10x_StdPeriph_Lib
    STM32F10x_StdPeriph_Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group System Core
    System Core/: stm32f10x_conf.h system.cpp system_stm32f10x.c
  group System Core/Startup
    STM32F10x_StdPeriph_Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
  group System Core/Vectors
    System Core/Vectors/: stm32f10x_it.c
  group USB
    USB/: scsi_data.c usb_bot.c usb_core.c usb_desc.c usb_endp.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_scsi.c
  group USB/Mass Storage Device
    USB/: memory.c usb_istr.c usb_prop.c usb_pwr.c
